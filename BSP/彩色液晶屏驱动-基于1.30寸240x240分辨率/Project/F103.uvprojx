# Keil uVision project F103.uvprojx, settings and files
target STM32F103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Drive\Source;..\Drive\Include;..\STM32\STM32F10x_StdPeriph_Driver\inc;..\MY;..\STM32\CMSIS\CM3\CoreSupport;..\STM32\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group MY
    ../MY/: main.c stm32f10x_it.c
  group Driver
    ../Drive/Source/: delay.c led.c usart.c lcd_fonts.c lcd_image.c lcd_spi_130.c
  group STM32
    ../STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_hd.s
    ../STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../STM32/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c
